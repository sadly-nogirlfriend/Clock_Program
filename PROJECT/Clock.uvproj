# Keil uVision project Clock.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: clock +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\SOURCE
  group Source Group 1
    ../SOURCE/: service_fun.c interrupt.c key.c led.c main.c timer.c
